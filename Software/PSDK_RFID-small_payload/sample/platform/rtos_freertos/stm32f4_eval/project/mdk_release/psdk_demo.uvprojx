# Keil uVision project psdk_demo.uvprojx, settings and files
target Psdk_Demo_Release_Use_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: psdk_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,PSDK_ARCH_SYS_RTOS=1
  c misc: --diag_suppress=188,177,550,940
  c include: ..\..\application;..\..\drivers\BSP;..\..\drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\CMSIS\Include;..\..\drivers\CMSIS\RTOS;..\..\drivers\STM32F4xx_HAL_Driver\Inc;..\..\middlewares\FreeRTOS\Source\CMSIS_RTOS;..\..\middlewares\FreeRTOS\Source\include;..\..\middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\psdk_lib\api_headers;..\..\..\common;..\..\;..\..\..\..\..\api_sample;..\..\drivers\BSP\uhflib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application/user
    ../../Application/: application.c main.c app_info.h
  group platform/osal
    ../../../common/osal/: osal.c
  group platform/hal
    ../../hal/: hal_uart.c
  group api_sample/camera
    ../../../../../api_sample/camera_emu/: test_payload_cam_emu.c
  group application/gimbal
    ../../../../../api_sample/gimbal_emu/: test_payload_gimbal_emu.c
  group api_sample/widget
    ../../../../../api_sample/widget/: test_widget.c file_binary_array_list_en.c
  group api_sample/time_synchronization
    ../../../../../api_sample/time_synchronization/: test_time_sync.c
  group api_sample/positioning
    ../../../../../api_sample/positioning/: test_positioning.c
  group api_sample/data_transmission
    ../../../../../api_sample/data_transmission/: test_data_transmission.c
  group api_sample/data_subscription
    ../../../../../api_sample/data_subscription/: test_data_subscription.c
  group api_sample/power_management
    ../../../../../api_sample/power_management/: test_power_management.c
  group api_sample/payload_collabration
    ../../../../../api_sample/payload_collaboration/: test_payload_collaboration.c
  group api_sample/xport
    ../../../../../api_sample/xport/: test_xport.c
  group api_sample/utils
    ../../../../../api_sample/utils/: util_misc.c util_md5.c
  group api_sample/upgrade
    ../../../../../api_sample/upgrade/: test_upgrade.c test_upgrade_common_file_transfer.c test_upgrade_platform_opt.c
    ../../drivers/BSP/: flash_if.c button.c
  group api_sample/data_channel
    ../../../../../api_sample/data_channel/: test_data_channel.c
  group mid/psdk_api_headers
    ../../../../../../psdk_lib/api_headers/: psdk_aircraft_info.h psdk_core.h psdk_data_subscription.h psdk_data_transmission.h psdk_logger.h psdk_payload_camera.h psdk_payload_collaboration.h psdk_platform.h psdk_positioning.h psdk_power_management.h psdk_typedef.h psdk_version.h psdk_widget.h psdk_gimbal.h psdk_xport.h psdk_data_channel.h
  group mid/freertos/port
    ../../Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../application/: FreeRTOSConfig.h
  group mid/freertos/src
    ../../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group drv/bsp
    ../../Drivers/BSP/: stm32f4xx_it.c dji_ringbuffer.c uart.c
    ../../drivers/BSP/: pps.c stm32f4xx_hal_msp.c apply_high_power.c upgrade_platform_opt_stm32.c led.c
  group drv/cmsis
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group drv/stm32f4_hal_driver
    ../../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group mid/psdk_lib
    ../../../../../../psdk_lib/lib/armcc_cortex-m4/: payloadsdk.lib
  group uhflibV4
    ../../drivers/BSP/uhflib/: uhf_demo.c uhflibV4.c
